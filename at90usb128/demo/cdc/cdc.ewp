# IAR project cdc.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: Pe111,Pe550
  ICCAVR.newCCIncludePaths: $PROJ_DIR$; conf; ../../; ../../../common/
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnkm128usb.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: cdc_task.c main.c uart_usb_lib.c usb_descriptors.c usb_specific_request.c
    ../../lib_mcu/power/: power_drv.c
    ../../../common/modules/scheduler/: scheduler.c
    ../../lib_board/stk_525/: stk_525.c
    ../../../common/lib_mcu/uart/: uart_lib.c
    ../../modules/usb/device_chap9/: usb_device_task.c usb_standard_request.c
    ../../lib_mcu/usb/: usb_drv.c
    ../../modules/usb/: usb_task.c
